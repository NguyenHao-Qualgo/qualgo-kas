BBCLASSEXTEND = "nativesdk native"